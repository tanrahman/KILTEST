# Keil uVision project CIU98M25_DemoCOS_Base.uvproj, settings and files
target CIU98M25_DemoCOS_Base (ARM-ADS)
  device: SC000 ARM
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("SC000") ESEL ELITTLE
  output: DemoCOS_Base +hex
  c flags: Optim=1 wLevel=2
  c include: .\INC
  memory RVCT4: ROM 0x0 size 0x11c000
  memory RVCT9: RAM 0x20000000 size 0xa000
  group SRC
    ./SRC/: startup.s main.c APDU_7816.c APDU_SWP_CARD.c SCI.c SubFunc.c Interrupt.c
  group API
    ./API/: HCI_lib_GVar.c CIU98M25_API_Base_NoNVM.c CIU98M25_API_NVM_STABILITY.c CIU98M25_API_LIB_SHA_RNG.lib CIU98M25_API_LIB_Stability.lib CIU98M25_ALG_LIB.lib CIU98M25_API_LIB_AES.lib CIU98M25_API_LIB_3DES.lib CIU98M25_API_LIB_DES.lib SWP_LIB_API_Kit_v1.9.lib
