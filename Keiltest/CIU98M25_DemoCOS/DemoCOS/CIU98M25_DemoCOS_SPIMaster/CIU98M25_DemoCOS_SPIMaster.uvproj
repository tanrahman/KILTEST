# Keil uVision project CIU98M25_DemoCOS_SPIMaster.uvproj, settings and files
target CIU98M25_DemoCOS_SPIMaster (ARM-ADS)
  device: SC000 ARM
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("SC000") ESEL ELITTLE
  output: DemoCOS_SPIMaster +hex
  c flags: Optim=1 wLevel=2
  c include: .\INC
  memory RVCT4: ROM 0x0 size 0x11c000
  memory RVCT9: RAM 0x20000000 size 0xa000
  group SRC
    ./SRC/: startup.s main.c SubFunc.c DEMO_APDU.c SPI.c
  group API
    ./API/: CIU98M25_API_Base_NoNVM.c CIU98M25_API_LIB_Stability.lib
